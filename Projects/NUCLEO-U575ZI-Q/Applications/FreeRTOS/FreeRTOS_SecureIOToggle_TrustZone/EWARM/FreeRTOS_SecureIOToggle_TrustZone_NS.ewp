# IAR project FreeRTOS_SecureIOToggle_TrustZone_NS.ewp, settings and files
configuration FreeRTOS_SecureIOToggle_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx; CMSIS_device_header="stm32u5xx.h"
  ICCARM.CCIncludePath2: ../NonSecure/Inc; ../Secure_nsclib; ../../../../../../Drivers/BSP/Components/mfxstm32l152; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc\Legacy; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33/non_secure; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33/secure; ../../../../../../Drivers/CMSIS/Include; ..\..\..\..\..\..\Drivers\BSP\STM32U5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\NonSecure\Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_SecureIOToggle_TrustZone_NS.hex
  ILINK.IlinkOutputFile: FreeRTOS_SecureIOToggle_TrustZone_NS.out
  ILINK.IlinkIcfFile: stm32u575xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/NonSecure
    ../NonSecure/Src/: app_freertos.c main.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx_ns.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33/non_secure/: port.c portasm.s
