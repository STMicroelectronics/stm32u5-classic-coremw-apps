<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO-U575ZI-Q.ewp</path>
  </project>
  <batchBuild/>
</workspace>
